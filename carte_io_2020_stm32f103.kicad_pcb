# Repository ClubRobotInsat/carte_io_2020_stm32f103

File readme.md:

## Carte I/O 2020
Fait sous kicad. Voir la [doc](https://clubrobotinsat.github.io/doc/).

## KiCad design carte_io_2020_stm32f103.kicad_pcb

Parts:
C1, C2: 1u; C_1206_3216Metric_Pad1.42x1.75mm_HandSolder
C3: 100uF; CP_Radial_D6.3mm_P2.50mm
D1: LED_hardfault_jaune; LED_D3.0mm
D2: LED_communication_vert; LED_D3.0mm
D3: led_feedback_vert; LED_D3.0mm
D4: LED_alimentation_rouge; LED_D3.0mm
J1: Connecteur gauche; PinSocket_1x20_P2.54mm_Vertical_Long_Pads
J3: Alim logique; TerminalBlock_Phoenix_MPT-0,5-3-2.54_1x03_P2.54mm_Horizontal
J4: Connecteur droit; PinSocket_1x20_P2.54mm_Vertical_Long_Pads
J8: Liaison serie; TerminalBlock_Phoenix_MPT-0,5-3-2.54_1x03_P2.54mm_Horizontal
J11: Tirette; TerminalBlock_Phoenix_MPT-0,5-2-2.54_1x02_P2.54mm_Horizontal
J12: Buzzer; HE14-3-straight
J13: FinCourse1; TerminalBlock_Phoenix_MPT-0,5-2-2.54_1x02_P2.54mm_Horizontal
J14: FinCourse2; TerminalBlock_Phoenix_MPT-0,5-2-2.54_1x02_P2.54mm_Horizontal
J15: FinCourse3; TerminalBlock_Phoenix_MPT-0,5-2-2.54_1x02_P2.54mm_Horizontal
J16: FinCourse4; TerminalBlock_Phoenix_MPT-0,5-2-2.54_1x02_P2.54mm_Horizontal
J17: FinCourse5; TerminalBlock_Phoenix_MPT-0,5-2-2.54_1x02_P2.54mm_Horizontal
J18: FinCourse6; TerminalBlock_Phoenix_MPT-0,5-2-2.54_1x02_P2.54mm_Horizontal
J19: FinCourse7; TerminalBlock_Phoenix_MPT-0,5-2-2.54_1x02_P2.54mm_Horizontal
J20: FinCourse8; TerminalBlock_Phoenix_MPT-0,5-2-2.54_1x02_P2.54mm_Horizontal
Q1, Q3, Q4: PMF370XN; SOT-323_SC-70_Handsoldering
R1, R4, R5, R6: 150; R_1206_3216Metric_Pad1.42x1.75mm_HandSolder
R_F1, R_F2, R_F3, R_F4, R_F5, R_F6, R_F7, R_F8: 10K; R_1206_3216Metric_Pad1.42x1.75mm_HandSolder
R_tirette1: 10K; R_1206_3216Metric_Pad1.42x1.75mm_HandSolder
U1: TC1262-33; SOT-223-3_TabPin2
U2: w5500

Connections:
+3V3: C2.1, U1.3 (VO), U2.10, U2.11
+5V: C1.1, C3.1, J1.18, J3.2, J11.2, J12.3, J13.2, J14.2, J15.2, J16.2, J17.2, J18.2, J19.2, J20.2, R1.1, R4.1, R5.1, R6.1, U1.1 (VI)
/CS: U2.2
/LED_couleur: J4.14
/MISO: J4.10, U2.7
/MOSI: J4.9, U2.4
/RX: J4.5, J8.3
/SCK: J4.11, U2.3
/TX: J4.6, J8.2
/buzzer: J12.1
/fin_course_1: J4.15, J13.1, R_F1.1
/fin_course_2: J4.16, J14.1, R_F2.1
/fin_course_3: J1.12, J15.1, R_F3.1
/fin_course_4: J1.13, J16.1, R_F4.1
/fin_course_5: J1.14, J17.1, R_F5.1
/fin_course_6: J1.15, J18.1, R_F6.1
/fin_course_7: J1.16, J19.1, R_F7.1
/fin_course_8: J1.17, J20.1, R_F8.1
/led_communication: J1.3, Q3.1 (G)
/led_feedback: J4.19, Q4.1 (G)
/led_hardfault: J1.1, Q1.1 (G)
/out_tirette: J4.7, J11.1, R_tirette1.1
GND: C1.2, C2.2, C3.2, D4.1 (K), J1.19, J3.1, J4.1, J4.2, J8.1, J12.2, Q1.2 (S), Q3.2 (S), Q4.2 (S), R_F1.2, R_F2.2, R_F3.2, R_F4.2, R_F5.2, R_F6.2, R_F7.2, R_F8.2, R_tirette1.2, U1.2 (GND), U2.5, U2.6, U2.12
unnamed: D1.1 (K), Q1.3 (D)
unnamed: D1.2 (A), R1.2
unnamed: D2.1 (K), Q3.3 (D)
unnamed: D2.2 (A), R4.2
unnamed: D3.1 (K), Q4.3 (D)
unnamed: D3.2 (A), R5.2
unnamed: D4.2 (A), R6.2

Notes on the sheet:
Alimentation
Led
input : 3.3v ou 5v
Microcontrolleur
Connectique
détrompeur
Doc pour le 3.3 -> 5 https://www.hobbytronics.co.uk/mosfet-voltage-level-converter
VBT
C13
C14
C15
B10
B11
RST
+3.3V
GND
+5V
A15
A12
A11
A10
B15
B14
B13
B12

Board: 2 copper layers, 39 parts (0 on the bottom side), 27 nets.

## Commit log

2020-03-02 fork: carte_io_2019_stm32f103
2020-03-02 adding pdf
2020-03-02 pré-routage
2020-10-20 adding readme
